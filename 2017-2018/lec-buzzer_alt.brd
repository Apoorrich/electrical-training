# Repository Apoorrich/electrical-training

## EAGLE design 2017-2018/lec-buzzer_alt.brd

Parts:
C1: 1.0uF; C0603
C2, C3: 0.1uF; C0603
C4, C5, C6: 1uF; C0603
C7: 10uF; C0603
D1: Blue; LED-0603
D2: Green; LED-0603
LCD1: LCD-S401C39TR; S401C39TR
LS1: PS1240P02BT
R1, R5: 150; R0603
R2, R3, R4: 10k; R0603
S1, S2, S3: SKQGADE010; SW4-SMD-5.2X5.2X1.5MM
U1, U2, U5, U6: 74HC595PW; SOT403-1
U3: DRV2605LDGSR; DGS10
U4: ATMEGA328P-AUR
X1: 2X3SHROUDED
X2: MINI-USB-32005-201; 32005-201

Connections:
1A: LCD1.35 (1A), U1.15 (Q0)
1B: LCD1.34 (1B), U1.1 (Q1)
1C: LCD1.7 (1C), U1.2 (Q2)
1D: LCD1.6 (1D), U1.3 (Q3)
1E: LCD1.5 (1E), U1.4 (Q4)
1F: LCD1.36 (1F), U1.5 (Q5)
1G: LCD1.37 (1G), U1.6 (Q6)
2A: LCD1.30 (2A), U2.15 (Q0)
2B: LCD1.29 (2B), U2.1 (Q1)
2C: LCD1.11 (2C), U2.2 (Q2)
2D: LCD1.10 (2D), U2.3 (Q3)
2E: LCD1.9 (2E), U2.4 (Q4)
2F: LCD1.31 (2F), U2.5 (Q5)
2G: LCD1.32 (2G), U2.6 (Q6)
3A: LCD1.25 (3A), U5.15 (Q0)
3B: LCD1.24 (3B), U5.1 (Q1)
3C: LCD1.15 (3C), U5.2 (Q2)
3D: LCD1.14 (3D), U5.3 (Q3)
3E: LCD1.13 (3E), U5.4 (Q4)
3F: LCD1.26 (3F), U5.5 (Q5)
3G: LCD1.27 (3G), U5.6 (Q6)
4A: LCD1.21 (4A), U6.15 (Q0)
4B: LCD1.20 (4B), U6.1 (Q1)
4C: LCD1.19 (4C), U6.2 (Q2)
4D: LCD1.18 (4D), U6.3 (Q3)
4E: LCD1.17 (4E), U6.4 (Q4)
4F: LCD1.22 (4F), U6.5 (Q5)
4G: LCD1.23 (4G), U6.6 (Q6)
!BTN2: C5.1, R4.1, S2.4 (B0), U4.23 (PC0_(ADC0/PCINT8))
!BTN3: C4.1, R3.1, S1.4 (B0), U4.24 (PC1_(ADC1/PCINT9))
!RESET: C6.1, R2.1, S3.1 (A0), U4.29 (PC6_(RESET/PCINT14)), X1.!RESET (5)
+5V: C2.1, C3.1, C7.1, D2.A, R2.2, S1.1 (A0), S2.1 (A0), U1.16 (VCC), U2.16 (VCC), U3.5 (EN), U3.10 (VDD), U4.4 (VCC_2), U4.6 (VCC), U4.18 (AVCC), U5.16 (VCC), U6.16 (VCC), X1.+5V (2), X2.1
COL: LCD1.28 (COL), U1.7 (Q7)
COM: LCD1.1 (COM1), LCD1.40 (COM2), U4.25 (PC2_(ADC2/PCINT10))
DP1: LCD1.8 (DP1), U2.7 (Q7)
DP2: LCD1.12 (DP2), U5.7 (Q7)
DP3: LCD1.16 (DP3), U6.7 (Q7)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R1.1, R3.2, R4.2, R5.1, S3.4 (B0), U1.8 (GND), U2.8 (GND), U3.4 (IN/TRIG), U3.8 (GND), U4.3 (GND_2), U4.5 (GND_3), U4.21 (GND), U5.8 (GND), U6.8 (GND), X1.GND (6), X2.5
LED1: D1.A, U4.14 ((PCINT2/SS/OC1B)_PB2)
LRA/ERM+: LS1.1 (A), U3.7 (OUT+)
LRA/ERM-: LS1.2 (B), U3.9 (OUT-)
MISO: U4.16 ((PCINT4/MISO)_PB4), X1.MISO (1)
MOSI: U4.15 ((PCINT3/OC2A/MOSI)_PB3), X1.MOSI (4)
unnamed: D1.C, R1.2
unnamed: D2.C, R5.2
unnamed: C1.1, U3.1 (REG)
SCK: U4.17 (PB5_(SCK/PCINT5)), X1.SCK (3)
SCL: U3.2 (SCL), U4.28 (PC5_(ADC5/SCL/PCINT13))
SDA: U3.3 (SDA), U4.27 (PC4_(ADC4/SDA/PCINT12))
SFT1-IN: U1.14 (DS), U4.13 ((PCINT1/OC1A)_PB1)
SFT2-IN: U1.9 (Q7S), U2.14 (DS)
SFT3-IN: U2.9 (Q7S), U5.14 (DS)
SFT4-IN: U5.9 (Q7S), U6.14 (DS)
SFT-!OE: U1.13 (!OE), U2.13 (!OE), U4.9 ((PCINT21/OC0B/T1)_PD5), U5.13 (!OE), U6.13 (!OE)
SFT-!RESET: U1.10 (!MR), U2.10 (!MR), U4.12 ((PCINT0/CLKO/ICP1)_PB0), U5.10 (!MR), U6.10 (!MR)
SFT-CLK: U1.11 (SHCP), U2.11 (SHCP), U4.11 ((PCINT23/AIN1)_PD7), U5.11 (SHCP), U6.11 (SHCP)
SFT-LATCH: U1.12 (STCP), U2.12 (STCP), U4.10 ((PCINT22/OC0A/AIN0)_PD6), U5.12 (STCP), U6.12 (STCP)

Notes on the sheet:
Make Button into interrupt

Board: 2 copper layers, 62.0 x 29.5 mm, 28 parts (2 on the bottom side), 57 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.6X

## Commit log

2017-11-02 Testcode

Notices in the files:
parts and their libraries:
SparkFun-LED: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
